# Repository guidodehek/InterfaceS88GleisboxRPi

File README.md:

# InterfaceS88GleisboxRPi
Interface pcb for controlling Märklin model railway using the Gleisbox (60116) and S88 via Rocrail.

## KiCad design pcb/InterfaceS88GleisboxRPi/InterfaceS88GleisboxRPi.kicad_pcb

Parts:
C1, C2: 22p; C_0805_2012Metric
C3, C4, C5, C7, C8, C9, C10: 100n; C_0805_2012Metric
C6: 10u; C_0805_2012Metric
C11: 1u; C_0805_2012Metric
D1, D2: LED; LED_0603_1608Metric
J1: PinSocket_2x20_P2.54mm_Vertical
J2: KMDGX-10S-BS; KMDGX10SBS; Mouser Part Number 806-KMDGX-10S-BS
J4: RJ45; 215877-1
J7: PJ-102AH; BarrelJack_CUI_PJ-102AH_Horizontal
R1: 120; R_0805_2012Metric
R2, R3, R4: 4k7; R_0805_2012Metric
R5: 330; R_0805_2012Metric
R6: 390; R_0805_2012Metric
R7, R11, R13: 270; R_0805_2012Metric
R8, R12, R14: 1k5; R_0805_2012Metric
R9: 680; R_0805_2012Metric
R10: 220; R_0805_2012Metric
R15, R16: 1k; R_0805_2012Metric
R17: 0; R_0805_2012Metric
SW1: SW_Push; SW_PUSH_6mm
U1: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U2: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U3: NME0505SC; Murata-NME0505SC-0-0-0; output voltage 5V; mouser part number 580-NME0505SC; digikey description CONV DC/DC 1W 5VIN 5VOUT SIP SGL
U4: LM317_SOT-223; SOT-223-3_TabPin2
U5, U6, U7, U8: 6N137; DIP-8_W7.62mm
Y1: 16Mhz; Crystal_HC50_Vertical

Connections:
+3.3V: C3.1, C4.1, J1.17 (3.3V), R2.2, R3.1, R4.2, R6.2, R7.1, R11.1, R13.1, U1.18 (VDD), U2.1 (VCC1)
+5V: C6.1, C7.1, C8.1, J1.2 (5V), U3.2 (+VIN), U8.7 (EN), U8.8 (VCC)
+5VA: C5.1, R16.2, U2.8 (VCC2), U3.4 (+VOUT)
+5VD: C9.1, C11.1, J4.1, R5.1, R8.1, R10.2, R12.1, R14.1, R15.2, U4.2 (VO), U5.7 (EN), U5.8 (VCC), U6.7 (EN), U6.8 (VCC), U7.7 (EN), U7.8 (VCC)
CS0: J1.24 (BCM8_CE0), R2.1, U1.16 (~CS)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, J1.6 (GND), J1.39 (GND), SW1.2, U1.9 (VSS), U2.4 (GND1), U3.1 (-VIN), U8.5 (GND)
GNDA: C5.2, D2.1 (K), J2.2, U2.5 (GND2), U3.3 (-VOUT)
GNDD: C9.2, C10.2, C11.2, D1.1 (K), J4.3, J4.5, J7.2, J7.3, R9.1, U5.5 (GND), U6.5 (GND), U7.5 (GND)
INT: J1.22 (BCM25), R3.2, U1.12 (~INT)
MISO: J1.21 (BCM9_MISO), U1.15 (SO)
MOSI: J1.19 (BCM10_MOSI), U1.14 (SI)
unnamed: D1.2 (A), R15.1
unnamed: D2.2 (A), R16.1
unnamed: R1.1, R17.2
unnamed: C2.1, U1.8 (OSC1), Y1.2
unnamed: C1.1, U1.7 (OSC2), Y1.1
unnamed: U1.2 (RXCAN), U2.2 (RXD)
unnamed: U1.1 (TXCAN), U2.3 (TXD)
unnamed: R4.1, U1.17 (~RESET)
unnamed: J2.7, R17.1, U2.7 (CANH)
unnamed: J2.10, R1.2, U2.6 (CANL)
unnamed: R9.2, R10.1, U4.1 (ADJ)
unnamed: C10.1, J7.1, U4.3 (VI)
unnamed: R7.2, U5.2 (A)
unnamed: R11.2, U6.2 (A)
unnamed: R13.2, U7.2 (A)
unnamed: R5.2, U8.2 (A)
S88_CLK: J4.4, R8.2, U5.6 (VO)
S88_CLK_3V3: J1.15 (BCM22), U5.3 (C)
S88_Data: J4.2, U8.3 (C)
S88_Data_3V3: J1.11 (BCM17), R6.1, U8.6 (VO)
S88_LOAD: J4.6, R12.2, U6.6 (VO)
S88_LOAD_3V3: J1.16 (BCM23), U6.3 (C)
S88_Reset: J4.7, R14.2, U7.6 (VO)
S88_Reset_3V3: J1.18 (BCM24), U7.3 (C)
SCLK: J1.23 (BCM11_SCLK), U1.13 (SCK)
Shutdown: J1.5 (BCM3_SCL), SW1.1

Notes on the sheet:
9 - 18 Vdc
IsolatedS88 Interface with external power supply
Isolated CAN Interface
Shutdown Button
Raspberry Pi Interface

Board: 2 copper layers, 65.0 x 56.5 mm, 46 parts (1 on the bottom side), 37 nets.

Other parts of the board:
H1, H2: RPi_Hat_Mounting_Hole

File pcb/InterfaceS88GleisboxRPi/BillOfMaterials.xlsx:

Reference | Value | Datasheet | Footprint | Qty | DNP | Available
C1,C2 | 22p | ~ | Capacitor_SMD:C_0805_2012Metric | 2 |  | 2
C3,C4,C5,C7,C8,C9,C10 | 100n | ~ | Capacitor_SMD:C_0805_2012Metric | 7 |  | 3
C6 | 10u | ~ | Capacitor_SMD:C_0805_2012Metric | 1 |  | 1
C11 | 1u | ~ | Capacitor_SMD:C_0805_2012Metric | 1 |  | 1
D1,D2 | LED | ~ | LED_SMD:LED_0603_1608Metric | 2 |  | 0
J1 | ~ |  | Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical | 1 |  | 0
J2 | KMDGX-10S-BS |  | CustomLib:KMDGX10SBS | 1 |  | 0
J4 | RJ45 | ~ | CustomLib:215877-1 | 1 |  | 0
J7 | PJ-102AH | ~ | Connector_BarrelJack:BarrelJack_CUI_PJ-102AH_Horizontal | 1 |  | 0
R1 | 120 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 0
R2,R3,R4 | 4k7 | ~ | Resistor_SMD:R_0805_2012Metric | 3 |  | 3
R5 | 330 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 1
R6 | 390 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 1
R7,R11,R13 | 270 | ~ | Resistor_SMD:R_0805_2012Metric | 3 |  | 0
R8,R12,R14 | 1k5 | ~ | Resistor_SMD:R_0805_2012Metric | 3 |  | 3
R9 | 680 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 1
R10 | 220 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 1
R15,R16 | 1k | ~ | Resistor_SMD:R_0805_2012Metric | 2 |  | 0
R17 | 0 | ~ | Resistor_SMD:R_0805_2012Metric | 1 |  | 0
SW1 | SW_Push | ~ | Button_Switch_THT:SW_PUSH_6mm | 1 |  | 0
U1 | MCP2515-xSO | http://ww1.microchip.com/downloads/en/DeviceDoc/21801e.pdf | Package_SO:SOIC-18W_7.5x11.6mm_P1.27mm | 1 |  | 1
U2 | ISO1050DUB | http://www.ti.com/lit/ds/symlink/iso1050.pdf | Package_SO:SOP-8_6.62x9.15mm_P2.54mm | 1 |  | 0
U3 | NME0505SC | https://power.murata.com/datasheet?/data/power/ncl/kdc_nme.pdf | CustomLib:Murata-NME0505SC-0-0-0 | 1 |  | 0
U4 | LM317_SOT-223 | http://www.ti.com/lit/ds/symlink/lm317.pdf | Package_TO_SOT_SMD:SOT-223-3_TabPin2 | 1 |  | 0
U5,U6,U7,U8 | 6N137 | https://docs.broadcom.com/docs/AV02-0940EN | Package_DIP:DIP-8_W7.62mm | 4 |  | 0
Y1 | 16Mhz | ~ | Crystal:Crystal_HC50_Vertical | 1 |  | 0

## Commit log

2023-01-06 feat: add documentation
    feat: add kicad project based on RPi_Hat template
2023-01-06 wip: initial schematic design
2023-01-06 wip: initial schematic design / layout
2023-01-06 wip: layout
2023-01-07 feat: perform drc
2023-01-11 feat: s88 circuit how has galvanic isolation and an external power input
2023-01-13 feat: use rj45 connector for s88
    fix: solve routing errors
2023-01-13 fix: solve routing warnings
2023-01-13 feat: change labels
2023-01-13 feat: generate gerbers and drill files
2023-01-26 feat: generate BOM
2023-02-22 bugfix: switched CAN-high and CAN-low connection to mini-din connector
2023-04-18 feat: template for manual
2023-04-18 wip: add chapters
2023-08-30 fix: issue with S88N pinning
2023-08-30 feat: instructions for using s88usp-rpi (gbert)
2023-08-31 fix: U8 must use rpi ground (GND) instead of GNDD on pin 5
2023-08-31 feat: add power status leds
    feat: increase track width of power lines
    feat: reroute for new power connector
2023-08-31 feat: simplify routing
2023-08-31 feat: add reverse polarity schottky diode
2023-08-31 feat: add S88n logo
2023-08-31 feat: update documentation
2023-11-04 fix: pcb sheet text
    fix: minor routing changes
    wip: manual for rpi preparation
2023-11-04 wip: can setup
2023-11-05 Update raspberrypisetup.tex
    use 32 bit PiOS
2023-12-05 feat: interface with PiCanS88 is working
    feat: installation of rocrail (cli)
    feat: use rdp
2023-12-06 fix: minor layout changes
    fix: minor manual changes
2024-03-18 fix: minor routing improvements
2024-03-18 feat: upgrade to kicad 8
2024-05-10 feat: s88 supply is smd
    feat: shuffle components
2024-05-10 feat: shutdown button
    feat: rotate 6N137 ICs
2024-05-11 fix: pads for 5Vdc supply are fixed
2024-05-11 feat: improve placing of components
2024-07-20 wip: save
2024-11-19 update manual
2024-12-19 Update installation instructions

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
